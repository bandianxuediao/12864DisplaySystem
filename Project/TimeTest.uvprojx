# Keil uVision project TimeTest.uvprojx, settings and files
target Timeer Test (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TimeTest +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\src;..\Libraries\inc;..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\User;..\HZ_Char;..\HardWare\OLED
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c stm32f10x_it.c delay.c sys.c ST7920.c
    ../HardWare/OLED/: display.c oled.c
  group Library
    ../Libraries/src/: misc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_rcc.c
  group CMSIS
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group StartUp
    ../Libraries/startup/: startup_stm32f10x_md.s
